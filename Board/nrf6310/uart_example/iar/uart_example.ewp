# IAR project uart_example.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: nRF51822-QFAA NordicSemi nRF51822-QFAA
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: DEBUG; NRF51; BOARD_NRF6310
  ICCARM.CCIncludePath2: ..\..\..\..\Include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: uart_example_iar.hex
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; NRF51; BOARD_NRF6310
  ICCARM.CCOptLevel: 3
  group (top)
    ../../../../Source/templates/iar/: iar_startup_nrf51.s
    ../: main.c radio_config.c radio_config.h
    ../../../../Source/simple_uart/: simple_uart.c
    ../../../../Source/templates/: system_nrf51.c
